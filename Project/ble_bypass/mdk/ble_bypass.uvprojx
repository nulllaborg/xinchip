# Keil uVision project ble_bypass.uvprojx, settings and files
target ble-sdk (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: ble_bypass
  AfterMake: fromelf --bin --output=s.bin !L
  AfterMake: Xincboot_tool s.bin ble_bypass.bin
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c include: ..\app;..\..\..\bsp\core;..\..\..\bsp\core\driver;..\..\..\bsp\core\startup;..\..\..\bsp\variants\xc620;..\..\..\bsp\core\ble;..\..\..\bsp\core\ble\btstack;..\..\..\bsp\core\ble\btstack\src\ble;..\..\..\bsp\core\ble\btstack\src\ble\gatt-service;..\..\..\bsp\core\ble\btstack\src\classic;..\..\..\bsp\variants\standard;..\..\..\bsp\core\ble\btstack\src
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x200
  scatter file: ..\..\..\bsp\core\startup\cpu.scat
  group startup
    ../../../bsp/core/startup/: core_cm0.c startup_xinc.s
  group application
    ../app/: main.c peripheral.c gatt_client.c sm_pairing_peripheral.c
  group ble
    ../../../bsp/core/ble/lib/: ble_sdk_nonlowpowerv1.2.lib
    ../../../bsp/core/ble/: patch.c
    ../../../bsp/core/driver/: rf_driver.c
  group bsp
    ../../../bsp/core/driver/: gpio.c gpio.h spi.c spi.h spi_flash.c spi_flash.h system.c system.h uart.c uart.h
  group arduino
    ../../../bsp/core/: board.c HardwareSerial1.c ringbuffer.c wiring_digital.c

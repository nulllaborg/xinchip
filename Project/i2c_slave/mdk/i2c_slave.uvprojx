# Keil uVision project i2c_slave.uvprojx, settings and files
target i2c_slave (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: i2c_slave +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c include: ..\..\..\bsp\core\startup;..\..\..\bsp\core;..\..\..\bsp\variants\standard;..\..\..\bsp\core\driver;..\..\..\bsp\variants\xc620
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\bsp\core\startup\cpu.scat
  group startup
    ../../../bsp/core/startup/: core_cm0.c startup_xinc.s
    ../../../bsp/core/driver/: system.c
  group application
    ../app/: main.c
  group bsp
    ../../../bsp/core/driver/: gpio.c uart.c i2c.c
    ../../../bsp/core/: board.c

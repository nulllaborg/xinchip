# Keil uVision project spi_gt20l16s1y_demo.uvprojx, settings and files
target spi_gt20l16s1y_demo (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: spi_gt20l16s1y_demo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c include: ..\..\..\bsp\core\startup;..\..\..\bsp\core;..\..\..\bsp\variants\standard;..\..\..\bsp\core\driver;..\..\..\bsp\variants\xc620;..\app
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\bsp\core\startup\cpu.scat
  group startup
    ../../../bsp/core/startup/: core_cm0.c startup_xinc.s
    ../../../bsp/core/driver/: system.c
  group application
    ../app/: main.c gt20l16s1y.c
  group bsp
    ../../../bsp/core/driver/: gpio.c uart.c spi.c
    ../../../bsp/core/: board.c

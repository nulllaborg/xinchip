# Keil uVision project ws2812b.uvprojx, settings and files
target ws2812b (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: ws2812b
  AfterMake: fromelf --bin --output=s.bin !L
  AfterMake: Xincboot_tool s.bin ws2812b.bin
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c include: ..\..\..\bsp\core\startup;..\..\..\bsp\core;..\..\..\bsp\variants\standard;..\..\..\bsp\core\driver;..\..\..\bsp\variants\xc620
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\bsp\core\startup\cpu.scat
  group startup
    ../../../bsp/core/startup/: core_cm0.c startup_xinc.s
    ../../../bsp/core/driver/: system.c
  group application
    ../app/: main.c ws2812b.c
    ../../../bsp/core/: HardwareSerial.c HardwareSerial1.c ringbuffer.c
  group bsp
    ../../../bsp/core/driver/: gpio.c uart.c spi.c
    ../../../bsp/core/: board.c
  group Include
    ../../../bsp/core/: Arduino.h
    ../../../bsp/variants/standard/: pins_arduino.h
    ../../../bsp/core/driver/: gpio.h
  group core
    ../../../bsp/core/: wiring_digital.c

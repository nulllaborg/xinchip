# Keil uVision project led.uvprojx, settings and files
target base-led (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: base-led
  AfterMake: fromelf --bin --output=s.bin !L
  AfterMake: Xincboot_tool s.bin base-led.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\bsp\core\startup;..\..\..\bsp\core;..\..\..\bsp\variants\standard;..\..\..\bsp\core\driver;..\..\..\bsp\variants\xc620
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\bsp\core\startup\cpu.scat
  group startup
    ../../../bsp/core/startup/: core_cm0.c startup_xinc.s system.c
  group application
    ../app/: main.c
  group bsp
    ../../../bsp/core/driver/: gpio.c
    ../../../bsp/variants/standard/: board.c
  group Include
    ../../../bsp/core/: Arduino.h
    ../../../bsp/variants/standard/: pins_arduino.h
    ../../../bsp/core/driver/: gpio.h
  group core
    ../../../bsp/core/: wiring_digital.c

# Keil uVision project adc.uvprojx, settings and files
target adc (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: adc
  AfterMake: fromelf --bin --output=s.bin !L
  AfterMake: Xincboot_tool s.bin adc.bin
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c include: ..\..\..\bsp\core\startup;..\..\..\bsp\core;..\..\..\bsp\variants\standard;..\..\..\bsp\core\driver;..\..\..\bsp\variants\xc620
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\bsp\core\startup\cpu.scat
  group startup
    ../../../bsp/core/startup/: core_cm0.c startup_xinc.s
    ../../../bsp/core/driver/: system.c
  group application
    ../app/: main.c
  group core
    ../../../bsp/core/: HardwareSerial1.c HardwareSerial.c ringbuffer.c wiring_analog.c
  group bsp
    ../../../bsp/core/driver/: adc.c gpio.c uart.c spi_flash.c

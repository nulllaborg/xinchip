# Keil uVision project Infrared_tracking.uvprojx, settings and files
target Infrared_tracking (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: Tracking_module +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c include: .\bsp;.\Include;.\startup;.\application;.\system_software
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\startup\cpu.scat
  group startup
    ./startup/: core_cm0.c system_xinc.c startup_xinc.s
  group bsp
    ./bsp/: bsp_gpio.c bsp_retarget.c bsp_i2c_master.c bsp_i2c_slave.c bsp_uart.c
  group Include
    ./Include/: Platform.h
  group application
    ./application/: main.c Infrared_core.c
  group system_software
    ./system_software/: Infrared.c
